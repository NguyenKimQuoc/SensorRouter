<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MyApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>MyApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>MyApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>MyApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>MyApp</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


